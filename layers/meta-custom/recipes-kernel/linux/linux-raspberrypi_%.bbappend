FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://custom-features.cfg"